## boards/touchpad_i2chid/Kconfig.shield
```kconfig
config SHIELD_TOUCHPAD_I2CHID
    bool "touchpad_i2chid shield"
    def_bool $(shields_list_contains,touchpad_i2chid)
    select I2C
```
